Commit message: Removed import of URDF

File: urdf/nerian.urdf.xacro (robot description, xacro)
@@ -61,6 +61,3 @@
     </joint>
   </xacro:macro>
-  <xacro:nerian_scarlet parent="top_plate_link">
-    <origin xyz="0 0 0.1" rpy="0 0 0"/>
-  </xacro:nerian_scarlet>
 </robot>
